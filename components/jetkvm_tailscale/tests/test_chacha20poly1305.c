/* RFC 8439 test vectors for the WireGuard ChaCha20 and ChaCha20-Poly1305 code. */
#include <stdint.h>
#include <stdio.h>
#include <stdlib.h>
#include <string.h>

#include "chacha20.h"
#include "chacha20poly1305.h"

static int failures;

static void expect_bytes(const char *name, const uint8_t *got, const uint8_t *want, size_t len) {
    if (memcmp(got, want, len) != 0) {
        printf("FAIL %s\n", name);
        failures++;
    } else {
        printf("ok   %s\n", name);
    }
}

/* Section 2.4.2: key 00..1f, nonce 00000000 0000004a 00000000, counter 1. */
static const char plaintext_2_4_2[] =
    "Ladies and Gentlemen of the class of '99: If I could offer you only one tip for "
    "the future, sunscreen would be it.";
static const uint8_t ciphertext_2_4_2[114] = { 0x6e, 0x2e, 0x35, 0x9a, 0x25, 0x68, 0xf9, 0x80, 0x41, 0xba, 0x07, 0x28, 0xdd, 0x0d, 0x69, 0x81, 0xe9, 0x7e, 0x7a, 0xec, 0x1d, 0x43, 0x60, 0xc2, 0x0a, 0x27, 0xaf, 0xcc, 0xfd, 0x9f, 0xae, 0x0b, 0xf9, 0x1b, 0x65, 0xc5, 0x52, 0x47, 0x33, 0xab, 0x8f, 0x59, 0x3d, 0xab, 0xcd, 0x62, 0xb3, 0x57, 0x16, 0x39, 0xd6, 0x24, 0xe6, 0x51, 0x52, 0xab, 0x8f, 0x53, 0x0c, 0x35, 0x9f, 0x08, 0x61, 0xd8, 0x07, 0xca, 0x0d, 0xbf, 0x50, 0x0d, 0x6a, 0x61, 0x56, 0xa3, 0x8e, 0x08, 0x8a, 0x22, 0xb6, 0x5e, 0x52, 0xbc, 0x51, 0x4d, 0x16, 0xcc, 0xf8, 0x06, 0x81, 0x8c, 0xe9, 0x1a, 0xb7, 0x79, 0x37, 0x36, 0x5a, 0xf9, 0x0b, 0xbf, 0x74, 0xa3, 0x5b, 0xe6, 0xb4, 0x0b, 0x8e, 0xed, 0xf2, 0x78, 0x5e, 0x42, 0x87, 0x4d };

/* Appendix A.5: AEAD decryption, nonce 00000000 01020304 05060708. */
static const uint8_t key_a5[32] = { 0x1c, 0x92, 0x40, 0xa5, 0xeb, 0x55, 0xd3, 0x8a, 0xf3, 0x33, 0x88, 0x86, 0x04, 0xf6, 0xb5, 0xf0, 0x47, 0x39, 0x17, 0xc1, 0x40, 0x2b, 0x80, 0x09, 0x9d, 0xca, 0x5c, 0xbc, 0x20, 0x70, 0x75, 0xc0 };
static const uint8_t ad_a5[12] = { 0xf3, 0x33, 0x88, 0x86, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x4e, 0x91 };
static const char plaintext_a5[] =
    "Internet-Drafts are draft documents valid for a maximum of six months and may be "
    "updated, replaced, or obsoleted by other documents at any time. It is inappropriate "
    "to use Internet-Drafts as reference material or to cite them other than as "
    "/\xe2\x80\x9cwork in progress./\xe2\x80\x9d";
static const uint8_t sealed_a5[265 + 16] = { 0x64, 0xa0, 0x86, 0x15, 0x75, 0x86, 0x1a, 0xf4, 0x60, 0xf0, 0x62, 0xc7, 0x9b, 0xe6, 0x43, 0xbd, 0x5e, 0x80, 0x5c, 0xfd, 0x34, 0x5c, 0xf3, 0x89, 0xf1, 0x08, 0x67, 0x0a, 0xc7, 0x6c, 0x8c, 0xb2, 0x4c, 0x6c, 0xfc, 0x18, 0x75, 0x5d, 0x43, 0xee, 0xa0, 0x9e, 0xe9, 0x4e, 0x38, 0x2d, 0x26, 0xb0, 0xbd, 0xb7, 0xb7, 0x3c, 0x32, 0x1b, 0x01, 0x00, 0xd4, 0xf0, 0x3b, 0x7f, 0x35, 0x58, 0x94, 0xcf, 0x33, 0x2f, 0x83, 0x0e, 0x71, 0x0b, 0x97, 0xce, 0x98, 0xc8, 0xa8, 0x4a, 0xbd, 0x0b, 0x94, 0x81, 0x14, 0xad, 0x17, 0x6e, 0x00, 0x8d, 0x33, 0xbd, 0x60, 0xf9, 0x82, 0xb1, 0xff, 0x37, 0xc8, 0x55, 0x97, 0x97, 0xa0, 0x6e, 0xf4, 0xf0, 0xef, 0x61, 0xc1, 0x86, 0x32, 0x4e, 0x2b, 0x35, 0x06, 0x38, 0x36, 0x06, 0x90, 0x7b, 0x6a, 0x7c, 0x02, 0xb0, 0xf9, 0xf6, 0x15, 0x7b, 0x53, 0xc8, 0x67, 0xe4, 0xb9, 0x16, 0x6c, 0x76, 0x7b, 0x80, 0x4d, 0x46, 0xa5, 0x9b, 0x52, 0x16, 0xcd, 0xe7, 0xa4, 0xe9, 0x90, 0x40, 0xc5, 0xa4, 0x04, 0x33, 0x22, 0x5e, 0xe2, 0x82, 0xa1, 0xb0, 0xa0, 0x6c, 0x52, 0x3e, 0xaf, 0x45, 0x34, 0xd7, 0xf8, 0x3f, 0xa1, 0x15, 0x5b, 0x00, 0x47, 0x71, 0x8c, 0xbc, 0x54, 0x6a, 0x0d, 0x07, 0x2b, 0x04, 0xb3, 0x56, 0x4e, 0xea, 0x1b, 0x42, 0x22, 0x73, 0xf5, 0x48, 0x27, 0x1a, 0x0b, 0xb2, 0x31, 0x60, 0x53, 0xfa, 0x76, 0x99, 0x19, 0x55, 0xeb, 0xd6, 0x31, 0x59, 0x43, 0x4e, 0xce, 0xbb, 0x4e, 0x46, 0x6d, 0xae, 0x5a, 0x10, 0x73, 0xa6, 0x72, 0x76, 0x27, 0x09, 0x7a, 0x10, 0x49, 0xe6, 0x17, 0xd9, 0x1d, 0x36, 0x10, 0x94, 0xfa, 0x68, 0xf0, 0xff, 0x77, 0x98, 0x71, 0x30, 0x30, 0x5b, 0xea, 0xba, 0x2e, 0xda, 0x04, 0xdf, 0x99, 0x7b, 0x71, 0x4d, 0x6c, 0x6f, 0x2c, 0x29, 0xa6, 0xad, 0x5c, 0xb4, 0x02, 0x2b, 0x02, 0x70, 0x9b, 0xee, 0xad, 0x9d, 0x67, 0x89, 0x0c, 0xbb, 0x22, 0x39, 0x23, 0x36, 0xfe, 0xa1, 0x85, 0x1f, 0x38 };
static const uint64_t nonce_a5 = 0x0807060504030201ULL;

static void test_stream_2_4_2(size_t offset) {
    uint8_t key[32];
    for (int i = 0; i < 32; i++) key[i] = (uint8_t)i;
    static _Alignas(4) uint8_t buffer[128 + 4];
    struct chacha20_ctx ctx;
    chacha20_init(&ctx, key, 0x4a000000ULL);
    ctx.state[12] = 1;
    memcpy(buffer + offset, plaintext_2_4_2, 114);
    chacha20(&ctx, buffer + offset, buffer + offset, 114);
    char name[64];
    snprintf(name, sizeof name, "RFC 8439 2.4.2 stream, offset %zu", offset);
    expect_bytes(name, buffer + offset, ciphertext_2_4_2, 114);
}

static void test_aead_a5(size_t offset) {
    static _Alignas(4) uint8_t sealed[265 + 16 + 4];
    static _Alignas(4) uint8_t opened[265 + 4];
    char name[64];

    memcpy(sealed + offset, sealed_a5, sizeof sealed_a5);
    snprintf(name, sizeof name, "RFC 8439 A.5 decrypt, offset %zu", offset);
    if (!chacha20poly1305_decrypt(opened + offset, sealed + offset, sizeof sealed_a5, ad_a5,
                                  sizeof ad_a5, nonce_a5, key_a5)) {
        printf("FAIL %s: tag rejected\n", name);
        failures++;
    } else {
        expect_bytes(name, opened + offset, (const uint8_t *)plaintext_a5, 265);
    }

    memcpy(opened + offset, plaintext_a5, 265);
    chacha20poly1305_encrypt(sealed + offset, opened + offset, 265, ad_a5, sizeof ad_a5,
                             nonce_a5, key_a5);
    snprintf(name, sizeof name, "RFC 8439 A.5 encrypt, offset %zu", offset);
    expect_bytes(name, sealed + offset, sealed_a5, sizeof sealed_a5);

    sealed[offset + 3] ^= 1;
    snprintf(name, sizeof name, "RFC 8439 A.5 altered ciphertext, offset %zu", offset);
    if (chacha20poly1305_decrypt(opened + offset, sealed + offset, sizeof sealed_a5, ad_a5,
                                 sizeof ad_a5, nonce_a5, key_a5)) {
        printf("FAIL %s: accepted\n", name);
        failures++;
    } else {
        printf("ok   %s\n", name);
    }
}

int main(void) {
    /* Offset 0 takes the word path for whole blocks; offsets 1 and 3 take the byte path. */
    for (size_t offset = 0; offset < 4; offset++) {
        test_stream_2_4_2(offset);
        test_aead_a5(offset);
    }
    if (failures) {
        printf("%d failures\n", failures);
        return 1;
    }
    return 0;
}
